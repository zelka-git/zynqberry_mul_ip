SRC_URI += "file://user_2019-04-02-16-50-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

