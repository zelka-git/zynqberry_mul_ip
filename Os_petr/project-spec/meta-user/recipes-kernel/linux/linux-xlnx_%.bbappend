SRC_URI += "file://user_2019-04-04-19-24-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

